Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Or
Time: 2020-07-01T11:56:33
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: ORA-MUL-001_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 42.9873; Area Measure: 4.98141; Volume Measure: 0.00530698

# IfcBuildingElementProxy: ORA-MUL-006_Default
In: Default Storey
Material: 6060
